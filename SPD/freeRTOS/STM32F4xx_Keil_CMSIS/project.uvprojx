# Keil uVision project project.uvprojx, settings and files
target Nucleo-F411 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_NUCLEO_F411,USE_INTERNAL_RC_CLOCK,PLL_M=16,PLL_N=400,PLL_P=4,PLL_Q=8
  c include: .\User;..\STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;.\User\FreeRTOS\Source\include;.\User\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group STD_Periph_Drivers
    ../STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group User
    ./User/: main.h main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group FreeRTOS
    ./User/FreeRTOS/Source/: list.c queue.c tasks.c timers.c croutine.c event_groups.c
    ./User/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./User/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
